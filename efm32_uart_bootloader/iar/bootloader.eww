<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\bootloader-gecko.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\bootloader-tg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\bootloader-tg-small.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\bootloader-giant.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\bootloader-tg110F32.ewp</path>
  </project>
   <project>
    <path>$WS_DIR$\bootloader-wg840F256.ewp</path>
  </project>
   <project>
    <path>$WS_DIR$\bootloader-tg222F32.ewp</path>
  </project>
     <project>
    <path>$WS_DIR$\bootloader-tg222F32_RS232x2.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\bootloader-zero.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\bootloader-zero108F32.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\bootloader-zero222F32.ewp</path>
  </project>
   <project>
    <path>$WS_DIR$\bootloader-zero222F32_RS232X2.ewp</path>
  </project>
  <batchBuild/>
</workspace>


