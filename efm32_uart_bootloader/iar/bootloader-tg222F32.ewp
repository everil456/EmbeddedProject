# IAR project bootloader-tg222F32.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32TG210F8 Silicon Labs EFM32TG210F8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32TG210F8
  ICCARM.CCIncludePath2: ..\..\..\CMSIS\Include; ..\..\..\Device\SiliconLabs\EFM32TG\Include; ..\src; ..\src\config_tg222F32; ..\..\arduino-1.5.2\hardware\arduino\em\system\EFM32TG\Include; ..\..\arduino-1.5.2\hardware\arduino\em\system\CMSIS\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\CMSIS\Include; ..\..\..\Device\SiliconLabs\EFM32TG\Include; ..\src; ..\src\config_tg
  OBJCOPY.OOCOutputFile: bootloader-tg.bin
  ILINK.IlinkOutputFile: bootloader-tg.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\EnergyMicro\EFM32TG210F32.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: EFM32TG222F32 EnergyMicro EFM32TG222F32
  ICCARM.CCDefines: NDEBUG; EFM32TG222F32
  ICCARM.CCIncludePath2: ..\..\..\CMSIS\Include; ..\..\..\Device\SiliconLabs\EFM32TG\Include; ..\src; ..\src\config_tg222F32; ..\..\arduino-1.5.2\hardware\arduino\em\system\CMSIS\Include; ..\..\arduino-1.5.2\hardware\arduino\em\system\EFM32TG\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ILINK.IlinkIcfFile: ..\src\bootloader.icf
  group Source
    ../src/: boot.c bootloader.c crc.c debug.c debuglock.c flash.c iarwrite.c startup_efm32.s usart.c xmodem.c
