# IAR project bootloader-zero222F32_RS232X2.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32ZG108F4 Silicon Labs EFM32ZG108F4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32ZG222F32
  ICCARM.CCIncludePath2: ..\..\..\CMSIS\Include; ..\..\..\Device\SiliconLabs\EFM32ZG\Include; ..\src; ..\src\config_zg222F32
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\CMSIS\Include; ..\..\..\Device\SiliconLabs\EFM32ZG\Include; ..\src; ..\src\config_zg
  OBJCOPY.OOCOutputFile: bootloader-zero222F32_RS232X2.bin
  ILINK.IlinkOutputFile: bootloader-zero222F32_RS232X2.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\EnergyMicro\EFM32ZG222F32.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32ZG222F32
  ICCARM.CCIncludePath2: ..\..\..\CMSIS\Include; ..\..\..\Device\SiliconLabs\EFM32ZG\Include; ..\src; ..\src\config_zg222F32_RS232X2; ..\..\arduino-1.5.2\hardware\arduino\em\system\CMSIS\Include; ..\..\arduino-1.5.2\hardware\arduino\em\system\EFM32ZG\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ILINK.IlinkIcfFile: ..\src\bootloader.icf
  group Source
    ../src/: boot.c bootloader.c crc.c debug.c debuglock.c flash.c iarwrite.c startup_efm32.s usart.c xmodem.c
